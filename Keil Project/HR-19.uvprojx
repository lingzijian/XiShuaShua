# Keil uVision project HR-19.uvprojx, settings and files
target HR-19 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HR-19 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER, ARM_MATH_CM3
  c include: ..\Source\App;..\Source\Core;..\Source\Dev;..\Source\FreeRTOS\include;..\Source\FreeRTOS\portable\RVDS\ARM_CM3;..\Source\System;..\Source\STM32F10x_FWLib\inc;..\Source\modbus\include;..\Source\modbus\ascii;..\Source\modbus\include;..\Source\modbus\rtu;..\Source\modbus\tcp;..\Source\modbus\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../Source/App/: main.c App_SysTask.c App_SystemExecute.c App_Communicate.c
  group Dev
    ../Source/Dev/: Dev_ADC.c Dev_IWDG.c Dev_Key.c Dev_LED.c Dev_RTC.c Dev_Timer.c Dev_UART.c Dev_Valve.c Dev_System.c Dev_XGZP6867.c Dev_FlowSensor.c Dev_ElectriGate.c Dev_Pump.c Dev_IIC.c Dev_M24Cxx.c Dev_TLV5618.c Dev_LevelProbe.c
  group Core
    ../Source/Core/: startup_stm32f10x_hd.s
  group FWLib
    ../Source/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../Source/System/: delay.c stm32f10x_it.c sys.c system_stm32f10x.c usart.c
  group FreeRTOS-Core
    ../Source/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Portable
    ../Source/FreeRTOS/portable/MemMang/: heap_4.c
    ../Source/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeModbus
    ../Source/modbus/: mb.c
    ../Source/modbus/tcp/: mbtcp.c
    ../Source/modbus/rtu/: mbcrc.c mbrtu.c
    ../Source/modbus/ascii/: mbascii.c
    ../Source/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Modbus-Port
    ../Source/modbus/port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
